## code/sdkconfig.defaults
```kconfig
CONFIG_PARTITION_TABLE_CUSTOM=y
CONFIG_PARTITION_TABLE_CUSTOM_FILENAME="partitions_esp_test.csv"
CONFIG_PARTITION_TABLE_FILENAME="partitions_esp_test.csv"
```
